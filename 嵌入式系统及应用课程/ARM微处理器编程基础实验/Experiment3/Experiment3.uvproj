# Keil uVision project Experiment3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM966E-S (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S) EBIG
  output: Experiment3
  c flags: Optim=1 OneElfS=1 wLevel=2
